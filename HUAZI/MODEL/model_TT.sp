.INC "SS/nmos.sp"
.INC "SS/pmos.sp"
