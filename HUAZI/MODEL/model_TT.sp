.INC "TT/nmos.sp"
.INC "TT/pmos.sp"
